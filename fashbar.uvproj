# Keil uVision project fashbar.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: fashbar +hex
  c flags: Optimize=8
  c define: FOSC_160000
  c include: .\Include
  group Source Group 1
    ./Startup/: STARTUP.A51
    ./Common/: Common.c Delay.c
    ./: main.c rfm219a.c UART.c PIO.c PWM.c ADC.c control_manager.c color_control.c action_service.c UserDataFlash_backup.c
